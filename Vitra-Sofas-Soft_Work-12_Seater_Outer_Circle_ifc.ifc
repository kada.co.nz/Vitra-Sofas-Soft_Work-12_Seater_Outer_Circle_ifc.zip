Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-12-20T16:08:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 20 16:08:26 2022 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\{BF619296-B9D0-439A-9AD2-0A0FB3F4B8F2}\ifc * Database version: 5507 * Database creation date: Tue Dec 20 16:08:25 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 20 16:08:25 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 20 16:08:25 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFurnishingElement: Soft Work - Sofa 1-seater convex 30° (12)
In: Level 1
Type - Material: Basic dark powder-coated 30, Polished Aluminium, Dark grey 69
Type - Dimensions - NominalDepth: 760.36 mm; NominalHeight: 870 mm; NominalLength: 1338.34 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Sofas-Soft_Work-1-seater-Convex_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_81; Uniclass2015Description: Sofas; Uniclass2015Reference: Pr_40_50_12_81; Version: 1; VersionDate: 13/12/2022
Type - Identity Data - Cost: 0; Manufacturer: Vitra; Model: Soft Work - Sofa 1-seater convex 30°; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; Type Name: Soft Work - Sofa 1-seater convex 30°
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Sofas-Soft_Work-1-seater-Convex_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Textile, metal; ModelNumber: n/a; ModelReference: n/a; Name: Soft_Work-1-seater-Convex_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 1350x750x860 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - BaseType_LeftControl: Soft-Work_Curved-Base_Full; BaseType_RightControl: Soft-Work_Curved-Base_Full; LegVisibility: yes
Dimensions - Area: 2.63846 m2; Volume: 0.792673 m3
Materials and Finishes - BaseMaterial: Basic dark powder-coated 30; CoverMaterial: Dark grey 69; SurfaceMaterial: Polished Aluminium; TableTopMaterial: Basic dark powder-coated 30
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Sofas-Soft_Work-1-seater-Convex_rfa: Soft Work - Sofa 1-seater convex 30°; Family and Type: Vitra-Sofas-Soft_Work-1-seater-Convex_rfa: Soft Work - Sofa 1-seater convex 30°; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Sofas-Soft_Work-1-seater-Convex_rfa: Soft Work - Sofa 1-seater convex 30°; Type Id: Vitra-Sofas-Soft_Work-1-seater-Convex_rfa: Soft Work - Sofa 1-seater convex 30°; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
Name (Vitra-Sofas-Soft_Work-1-seater-Convex_rfa:Soft Work - Sofa 1-seater convex 30°:...)
977762
977769
977854
977911
982850
982861
982871
982881
982891
982902
982913
982951
